# Keil uVision project download.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F405RG STMicroelectronics
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: download +hex
  c flags: Optim=1 wLevel=2
  c include: ..\UCOSII\CONFIG;..\UCOSII\CORE;..\UCOSII\PORT;..\Lib
  asm define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: startup_stm32f4xx.s
    ../User/: download.c download_data.c Guidance_System.c IMU.c main.c misc.c stm32f4xx_dma.c stm32f4xx_gpio.c stm32f4xx_it.c stm32f4xx_pwr.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c system_stm32f4xx.c waijung_hwdrvlib.c app_task.c stm32f4xx_flash.c rtGetInf.c rtGetNaN.c rt_nonfinite.c
  group UCOSII-CORE
    ../UCOSII/CORE/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII-PORT
    ../UCOSII/PORT/: os_cpu.h os_cpu_a.asm os_cpu_c.c
  group UCOSII-CONFIG
    ../UCOSII/CONFIG/: includes.h os_cfg.h app_cfg.h app_task.h core_cm4.h core_cm4_simd.h core_cmFunc.h core_cmInstr.h download.h download_private.h download_types.h ext_work.h Guidance_System.h IMU.h misc.h rt_logging.h rtmodel.h rtwtypes.h stm32f4xx.h stm32f4xx_conf.h stm32f4xx_dma.h stm32f4xx_gpio.h stm32f4xx_it.h stm32f4xx_pwr.h stm32f4xx_rcc.h stm32f4xx_syscfg.h stm32f4xx_tim.h stm32f4xx_usart.h system_stm32f4xx.h waijung_hwdrvlib.h
